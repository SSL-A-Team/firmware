<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\cube_mx_hal.ewp</path>
  </project>
  <batchBuild />
</workspace>
